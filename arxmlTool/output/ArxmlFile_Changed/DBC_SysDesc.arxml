[part 3 of 6: package /DBC_SysDesc_P_CANFD/Pkg_Cluster]
AUTOSAR XML (schema 4-2-2)
package /DBC_SysDesc_P_CANFD/Pkg_Cluster  (continued)
  can cluster P_CANFD: baudrate=500000, protocol-name=CAN, can-fd-baudrate=2000000  (continued)
    can physical channel P_CANFD_Channel: comm-connectors=Conn_P_CANFD_MVCU  (continued)
      frame MCUM_0x5D3: id 0x5D3, from MVCU, frame-length=64, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu MCUM_0x5D3: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu MCUM_0x5D3: length=64, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.2}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.2}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_StatorTemp_1}
            {data-filter={data-filter-type=ALWAYS, max=1023, min=0}, i-signal-in-i-pdu=MCUM_L2TqAct}
            {data-filter={data-filter-type=ALWAYS, max=131071, min=0}, i-signal-in-i-pdu=MCUM_EOPSw}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_StatorTemp_2}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_IGBTTemp_U}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_IGBTTemp_V}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_IGBTTemp_W}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_PCBTemp}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Power_12V}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Power_15V}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Offset_IU}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Offset_IV}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Offset_IW}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_MainSt_State}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Derate_Reason}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_PWM_Freq_kHz}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_PWMEn_State}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_DrvPwrEn_Out_State}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_SBC_SelfCheckFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_SBC_TempOverFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_SBC_SPIFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_SBC_InsideVotageFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_SBC_OutPutVotageFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_SBC_FeedDogFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVM_RslvrZeroRFault}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=3600, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Rotor_Position}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_PosTransduserFaultCode}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVM_RslvrDirRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVM_RslvrDelayRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVM_RslvrParamRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVM_HallGainRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVM_HallDelayRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVM_IGBTTypeRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVM_MotorTypeRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVM_VehicleTypeRFault}
            {data-filter={data-filter-type=ALWAYS, max=31, min=0, offset=0}, i-signal-in-i-pdu=MCUM_ASC_EntryCount}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=17000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Spd_Turn}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=17000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_LUT_Spd_Max}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=8191, min=0}, i-signal-in-i-pdu=MCUM_EOP_Speed}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_EOP_IqFb}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_EOP_IqRef}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=300, min=0, offset=0}, i-signal-in-i-pdu=MCUM_EOP_DCVolt}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_EOP_DCCurr}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_EOP_Temp}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_EOP_State}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=MCUM_EOP_FaultCode}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_HWFault_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_HWFoB_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_HWFoT_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_HWDrvUV_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_HWRdc_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_HWOC_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_HWOV_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_L2agRtrElecDiff}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_500usOverTime_Cnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_5msOverTime_Cnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_12VHop_Cnt}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_12V_Max}
            {data-filter={data-filter-type=ALWAYS, max=200, min=0, offset=0}, i-signal-in-i-pdu=MCUM_12V_Min}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_NVMFail_Cnt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_EOL_CANCommReq}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_ResetReason}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=MCUM_CpldRest_TimeOut_flag}
            {data-filter={data-filter-type=ALWAYS, max=30, min=0, offset=0}, i-signal-in-i-pdu=MCUM_DrvPCBCurr}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_EOL_StateMachine}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_CpldRest_ASC_Flag}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_LimSpdTorFlag}
            {data-filter={data-filter-type=ALWAYS, max=31, min=0, offset=0}, i-signal-in-i-pdu=MCUM_PWM_Err_Count}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_RDC_Reset_Count}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_ASC_Stop_Flag}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_ASC_Soft_Exiting_Flag}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Vbus_ServeLowChkEn}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_EOP_BlockErr_IsLim_Flag}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=MCUM_MotSelfHeat_EnSts}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=MCUM_MotBlockHeat_LvlFb}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=MCUM_MotRotaryHeat_LvlFb}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_MotSelfHeat_DropLvlFb}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=MCUM_MotSelfHeat_DropLvlRsn}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=360, min=0, offset=0}, i-signal-in-i-pdu=MCUM_MotBlockHeat_CurAngle}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_MotBlockHeat_CurMag}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_FaultDataRec_State}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_UserDefine_Byte{1..4}}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=65535, min=0, offset=0}, i-signal-in-i-pdu=MCUM_UserDefine_Word{1..3}}
          signal MCUM_StatorTemp_1: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_StatorTemp_1, update-indication-bit-position=-1
          signal MCUM_L2TqAct: start 388, 10 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_L2TqAct, update-indication-bit-position=-1
          signal MCUM_EOPSw: start 337, 17 bit, little-endian, init-value=0, base-type=uint32, implementation-data-type=DT_MCUM_EOPSw, update-indication-bit-position=-1
          signal MCUM_StatorTemp_2: start 8, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_StatorTemp_2, update-indication-bit-position=-1
          signal MCUM_IGBTTemp_U: start 16, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_IGBTTemp_U, update-indication-bit-position=-1
          signal MCUM_IGBTTemp_V: start 24, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_IGBTTemp_V, update-indication-bit-position=-1
          signal MCUM_IGBTTemp_W: start 32, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_IGBTTemp_W, update-indication-bit-position=-1
          signal MCUM_PCBTemp: start 40, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_PCBTemp, update-indication-bit-position=-1
          signal MCUM_Power_12V: start 48, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_Power_12V, update-indication-bit-position=-1
          signal MCUM_Power_15V: start 56, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_Power_15V, update-indication-bit-position=-1
          signal MCUM_Offset_IU: start 64, 13 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Offset_IU, update-indication-bit-position=-1
          signal MCUM_Offset_IV: start 77, 13 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Offset_IV, update-indication-bit-position=-1
          signal MCUM_Offset_IW: start 90, 13 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Offset_IW, update-indication-bit-position=-1
          signal MCUM_MainSt_State: start 103, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_MainSt_State, update-indication-bit-position=-1
          signal MCUM_Derate_Reason: start 107, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_Derate_Reason, update-indication-bit-position=-1
          signal MCUM_PWM_Freq_kHz: start 111, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_PWM_Freq_kHz, update-indication-bit-position=-1
          signal MCUM_PWMEn_State: start 119, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_PWMEn_State, update-indication-bit-position=-1
          signal MCUM_DrvPwrEn_Out_State: start 120, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_DrvPwrEn_Out_State, update-indication-bit-position=-1
          signal MCUM_SBC_SelfCheckFault: start 121, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_SBC_SelfCheckFault, update-indication-bit-position=-1
          signal MCUM_SBC_TempOverFault: start 122, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_SBC_TempOverFault, update-indication-bit-position=-1
          signal MCUM_SBC_SPIFault: start 123, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_SBC_SPIFault, update-indication-bit-position=-1
          signal MCUM_SBC_InsideVotageFault: start 124, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_SBC_InsideVotageFault, update-indication-bit-position=-1
          signal MCUM_SBC_OutPutVotageFault: start 125, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_SBC_OutPutVotageFault, update-indication-bit-position=-1
          signal MCUM_SBC_FeedDogFault: start 126, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_SBC_FeedDogFault, update-indication-bit-position=-1
          signal MCUM_NVM_RslvrZeroRFault: start 127, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVM_RslvrZeroRFault, update-indication-bit-position=-1
          signal MCUM_Rotor_Position: start 128, 13 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Rotor_Position, update-indication-bit-position=-1
          signal MCUM_PosTransduserFaultCode: start 141, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_PosTransduserFaultCode, update-indication-bit-position=-1
          signal MCUM_NVM_RslvrDirRFault: start 149, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVM_RslvrDirRFault, update-indication-bit-position=-1
          signal MCUM_NVM_RslvrDelayRFault: start 150, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVM_RslvrDelayRFault, update-indication-bit-position=-1
          signal MCUM_NVM_RslvrParamRFault: start 151, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVM_RslvrParamRFault, update-indication-bit-position=-1
          signal MCUM_NVM_HallGainRFault: start 152, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVM_HallGainRFault, update-indication-bit-position=-1
          signal MCUM_NVM_HallDelayRFault: start 153, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVM_HallDelayRFault, update-indication-bit-position=-1
          signal MCUM_NVM_IGBTTypeRFault: start 154, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVM_IGBTTypeRFault, update-indication-bit-position=-1
          signal MCUM_NVM_MotorTypeRFault: start 155, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVM_MotorTypeRFault, update-indication-bit-position=-1
          signal MCUM_NVM_VehicleTypeRFault: start 156, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVM_VehicleTypeRFault, update-indication-bit-position=-1
          signal MCUM_ASC_EntryCount: start 157, 5 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_ASC_EntryCount, update-indication-bit-position=-1
          signal MCUM_Spd_Turn: start 162, 15 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Spd_Turn, update-indication-bit-position=-1
          signal MCUM_LUT_Spd_Max: start 177, 15 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_LUT_Spd_Max, update-indication-bit-position=-1
          signal MCUM_EOP_Speed: start 192, 13 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_EOP_Speed, update-indication-bit-position=-1
          signal MCUM_EOP_IqFb: start 205, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_EOP_IqFb, update-indication-bit-position=-1
          signal MCUM_EOP_IqRef: start 214, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_EOP_IqRef, update-indication-bit-position=-1
          signal MCUM_EOP_DCVolt: start 223, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_EOP_DCVolt, update-indication-bit-position=-1
          signal MCUM_EOP_DCCurr: start 232, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_EOP_DCCurr, update-indication-bit-position=-1
          signal MCUM_EOP_Temp: start 241, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_EOP_Temp, update-indication-bit-position=-1
          signal MCUM_EOP_State: start 249, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_EOP_State, update-indication-bit-position=-1
          signal MCUM_EOP_FaultCode: start 253, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_EOP_FaultCode, update-indication-bit-position=-1
          signal MCUM_HWFault_RstCnt: start 256, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_HWFault_RstCnt, update-indication-bit-position=-1
          signal MCUM_HWFoB_RstCnt: start 260, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_HWFoB_RstCnt, update-indication-bit-position=-1
          signal MCUM_HWFoT_RstCnt: start 264, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_HWFoT_RstCnt, update-indication-bit-position=-1
          signal MCUM_HWDrvUV_RstCnt: start 268, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_HWDrvUV_RstCnt, update-indication-bit-position=-1
          signal MCUM_HWRdc_RstCnt: start 272, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_HWRdc_RstCnt, update-indication-bit-position=-1
          signal MCUM_HWOC_RstCnt: start 276, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_HWOC_RstCnt, update-indication-bit-position=-1
          signal MCUM_HWOV_RstCnt: start 280, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_HWOV_RstCnt, update-indication-bit-position=-1
          signal MCUM_L2agRtrElecDiff: start 284, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_L2agRtrElecDiff, update-indication-bit-position=-1
          signal MCUM_500usOverTime_Cnt: start 288, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_500usOverTime_Cnt, update-indication-bit-position=-1
          signal MCUM_5msOverTime_Cnt: start 292, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_5msOverTime_Cnt, update-indication-bit-position=-1
          signal MCUM_12VHop_Cnt: start 296, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_12VHop_Cnt, update-indication-bit-position=-1
          signal MCUM_12V_Max: start 300, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_12V_Max, update-indication-bit-position=-1
          signal MCUM_12V_Min: start 308, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_12V_Min, update-indication-bit-position=-1
          signal MCUM_NVMFail_Cnt: start 316, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_NVMFail_Cnt, update-indication-bit-position=-1
          signal MCUM_EOL_CANCommReq: start 320, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_EOL_CANCommReq, update-indication-bit-position=-1
          signal MCUM_ResetReason: start 321, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_ResetReason, update-indication-bit-position=-1
          signal MCUM_CpldRest_TimeOut_flag: start 354, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_CpldRest_TimeOut_flag, update-indication-bit-position=-1
          signal MCUM_DrvPCBCurr: start 356, 5 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_DrvPCBCurr, update-indication-bit-position=-1
          signal MCUM_EOL_StateMachine: start 361, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_EOL_StateMachine, update-indication-bit-position=-1
          signal MCUM_CpldRest_ASC_Flag: start 369, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_CpldRest_ASC_Flag, update-indication-bit-position=-1
          signal MCUM_LimSpdTorFlag: start 370, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_LimSpdTorFlag, update-indication-bit-position=-1
          signal MCUM_PWM_Err_Count: start 371, 5 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_PWM_Err_Count, update-indication-bit-position=-1
          signal MCUM_RDC_Reset_Count: start 376, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_RDC_Reset_Count, update-indication-bit-position=-1
          signal MCUM_ASC_Stop_Flag: start 384, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_ASC_Stop_Flag, update-indication-bit-position=-1
          signal MCUM_ASC_Soft_Exiting_Flag: start 385, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_ASC_Soft_Exiting_Flag, update-indication-bit-position=-1
          signal MCUM_Vbus_ServeLowChkEn: start 386, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_Vbus_ServeLowChkEn, update-indication-bit-position=-1
          signal MCUM_EOP_BlockErr_IsLim_Flag: start 387, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_EOP_BlockErr_IsLim_Flag, update-indication-bit-position=-1
          signal MCUM_MotSelfHeat_EnSts: start 399, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_MotSelfHeat_EnSts, update-indication-bit-position=-1
          signal MCUM_MotBlockHeat_LvlFb: start 401, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_MotBlockHeat_LvlFb, update-indication-bit-position=-1
          signal MCUM_MotRotaryHeat_LvlFb: start 404, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_MotRotaryHeat_LvlFb, update-indication-bit-position=-1
          signal MCUM_MotSelfHeat_DropLvlFb: start 407, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_MotSelfHeat_DropLvlFb, update-indication-bit-position=-1
          signal MCUM_MotSelfHeat_DropLvlRsn: start 408, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_MotSelfHeat_DropLvlRsn, update-indication-bit-position=-1
          signal MCUM_MotBlockHeat_CurAngle: start 410, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_MotBlockHeat_CurAngle, update-indication-bit-position=-1
          signal MCUM_MotBlockHeat_CurMag: start 419, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_MotBlockHeat_CurMag, update-indication-bit-position=-1
          signal MCUM_FaultDataRec_State: start 428, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_FaultDataRec_State, update-indication-bit-position=-1
          signal MCUM_UserDefine_Byte1: start 432, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_UserDefine_Byte1, update-indication-bit-position=-1
          signal MCUM_UserDefine_Byte2: start 440, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_UserDefine_Byte2, update-indication-bit-position=-1
          signal MCUM_UserDefine_Byte3: start 448, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_UserDefine_Byte3, update-indication-bit-position=-1
          signal MCUM_UserDefine_Byte4: start 456, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_MCUM_UserDefine_Byte4, update-indication-bit-position=-1
          signal MCUM_UserDefine_Word1: start 464, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_UserDefine_Word1, update-indication-bit-position=-1
          signal MCUM_UserDefine_Word2: start 480, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_UserDefine_Word2, update-indication-bit-position=-1
          signal MCUM_UserDefine_Word3: start 496, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_UserDefine_Word3, update-indication-bit-position=-1
      frame VCU_0xBB: id 0xBB, from MVCU, frame-length=32, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu VCU_0xBB: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu VCU_0xBB: length=32, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=VCU_CheckSum_BB}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=VCU_WorkModeReq_PHEV}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=VCU_WorkMode_PHEV}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_HEVAllow_PHEV}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_REAllow_PHEV}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EVDualAllow_PHEV}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EVSingleAllow_PHEV}
            {data-filter={data-filter-type=ALWAYS, max=65535, min=0, offset=0}, i-signal-in-i-pdu=VCU_Clutch_2_RequesSpeed}
            {data-filter={data-filter-type=ALWAYS, max=65535, min=0, offset=0}, i-signal-in-i-pdu=VCU_Clutch_1_RequesSpeed}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_Clutch2Position}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_Clutch1Position}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=VCU_RollingCounter_BB}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngPreStartFlg}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_FuelChgModeMsg}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_FuelChgModeSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_RoughRoadDetectionFlag}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_Clutch_2_RequesSpeedValid}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_Clutch_1_RequesSpeedValid}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=VCU_GCURequestTorque}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_PowerReducetSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_GCUAassistFB}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_GCUActiveReleaseCmd}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_PowerOverSts}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=16000, min=0}, i-signal-in-i-pdu=VCU_GCURequesSpeed}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_GCUControlMode}
            {data-filter={data-filter-type=ALWAYS, max=254, min=0, offset=0}, i-signal-in-i-pdu=VCU_MotChargePower}
            {data-filter={data-filter-type=ALWAYS, max=254, min=0, offset=0}, i-signal-in-i-pdu=VCU_APS1Position}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngineStartReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngineFuelInhibitReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngineOffRequest}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_STorqueReqValid}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4094, min=0}, i-signal-in-i-pdu=VCU_STorqueReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_FTorqueSwFb}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_FVVOpenReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_WarmUpCycleIndicator}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngineResetSts}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngineSts}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4094, min=0}, i-signal-in-i-pdu=VCU_FTorqueReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_FTorqueReqValid}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngineIdleReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_REsystemSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_REsystemFaultSts}
            {data-filter={data-filter-type=ALWAYS, max=254, min=0, offset=0}, i-signal-in-i-pdu=VCU_APS2Position}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngineRunAllowFlg}
            {data-filter={data-filter-type=ALWAYS, max=2, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngineIdleSpeed}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_EngineFuleCutoffReq}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_MCUSClutchPosition}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_MGCUWorkMode}
            {data-filter={data-filter-type=ALWAYS, max=100, min=0, offset=0}, i-signal-in-i-pdu=VCU_REChgTarget}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=VCU_MotStartStopPowerUP}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=VCU_MotStartStopPowerLOW}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=47000, min=0}, i-signal-in-i-pdu=VCU_GCURequesSpeed_MGCU}
            {data-filter={data-filter-type=ALWAYS, max=20, min=0}, i-signal-in-i-pdu=VCU_DynamicChgPwr}
            {data-filter={data-filter-type=ALWAYS, max=20, min=0}, i-signal-in-i-pdu=VCU_ForceChgPwr}
            {data-filter={data-filter-type=ALWAYS, max=31, min=0, offset=0}, i-signal-in-i-pdu=VCU_REStartType}
          signal VCU_CheckSum_BB: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_CheckSum_BB, update-indication-bit-position=-1
          signal VCU_WorkModeReq_PHEV: start 219, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_WorkModeReq_PHEV, update-indication-bit-position=-1
          signal VCU_WorkMode_PHEV: start 216, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_WorkMode_PHEV, update-indication-bit-position=-1
          signal VCU_HEVAllow_PHEV: start 215, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_HEVAllow_PHEV, update-indication-bit-position=-1
          signal VCU_REAllow_PHEV: start 214, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_REAllow_PHEV, update-indication-bit-position=-1
          signal VCU_EVDualAllow_PHEV: start 213, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EVDualAllow_PHEV, update-indication-bit-position=-1
          signal VCU_EVSingleAllow_PHEV: start 212, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EVSingleAllow_PHEV, update-indication-bit-position=-1
          signal VCU_Clutch_2_RequesSpeed: start 196, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_Clutch_2_RequesSpeed, update-indication-bit-position=-1
          signal VCU_Clutch_1_RequesSpeed: start 180, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_Clutch_1_RequesSpeed, update-indication-bit-position=-1
          signal VCU_Clutch2Position: start 178, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_Clutch2Position, update-indication-bit-position=-1
          signal VCU_Clutch1Position: start 176, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_Clutch1Position, update-indication-bit-position=-1
          signal VCU_RollingCounter_BB: start 8, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_RollingCounter_BB, update-indication-bit-position=-1
          signal VCU_EngPreStartFlg: start 228, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngPreStartFlg, update-indication-bit-position=-1
          signal VCU_FuelChgModeMsg: start 226, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_FuelChgModeMsg, update-indication-bit-position=-1
          signal VCU_FuelChgModeSts: start 224, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_FuelChgModeSts, update-indication-bit-position=-1
          signal VCU_RoughRoadDetectionFlag: start 47, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_RoughRoadDetectionFlag, update-indication-bit-position=-1
          signal VCU_Clutch_2_RequesSpeedValid: start 223, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_Clutch_2_RequesSpeedValid, update-indication-bit-position=-1
          signal VCU_Clutch_1_RequesSpeedValid: start 222, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_Clutch_1_RequesSpeedValid, update-indication-bit-position=-1
          signal VCU_GCURequestTorque: start 16, 12 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_GCURequestTorque, update-indication-bit-position=-1
          signal VCU_PowerReducetSts: start 28, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_PowerReducetSts, update-indication-bit-position=-1
          signal VCU_GCUAassistFB: start 29, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_GCUAassistFB, update-indication-bit-position=-1
          signal VCU_GCUActiveReleaseCmd: start 30, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_GCUActiveReleaseCmd, update-indication-bit-position=-1
          signal VCU_PowerOverSts: start 31, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_PowerOverSts, update-indication-bit-position=-1
          signal VCU_GCURequesSpeed: start 32, 14 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_GCURequesSpeed, update-indication-bit-position=-1
          signal VCU_GCUControlMode: start 46, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_GCUControlMode, update-indication-bit-position=-1
          signal VCU_MotChargePower: start 48, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MotChargePower, update-indication-bit-position=-1
          signal VCU_APS1Position: start 56, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_APS1Position, update-indication-bit-position=-1
          signal VCU_EngineStartReq: start 64, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngineStartReq, update-indication-bit-position=-1
          signal VCU_EngineFuelInhibitReq: start 65, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngineFuelInhibitReq, update-indication-bit-position=-1
          signal VCU_EngineOffRequest: start 66, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngineOffRequest, update-indication-bit-position=-1
          signal VCU_STorqueReqValid: start 67, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_STorqueReqValid, update-indication-bit-position=-1
          signal VCU_STorqueReq: start 68, 12 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_STorqueReq, update-indication-bit-position=-1
          signal VCU_FTorqueSwFb: start 80, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_FTorqueSwFb, update-indication-bit-position=-1
          signal VCU_FVVOpenReq: start 81, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_FVVOpenReq, update-indication-bit-position=-1
          signal VCU_WarmUpCycleIndicator: start 82, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_WarmUpCycleIndicator, update-indication-bit-position=-1
          signal VCU_EngineResetSts: start 83, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngineResetSts, update-indication-bit-position=-1
          signal VCU_EngineSts: start 84, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngineSts, update-indication-bit-position=-1
          signal VCU_FTorqueReq: start 88, 12 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_FTorqueReq, update-indication-bit-position=-1
          signal VCU_FTorqueReqValid: start 100, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_FTorqueReqValid, update-indication-bit-position=-1
          signal VCU_EngineIdleReq: start 101, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngineIdleReq, update-indication-bit-position=-1
          signal VCU_REsystemSts: start 102, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_REsystemSts, update-indication-bit-position=-1
          signal VCU_REsystemFaultSts: start 103, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_REsystemFaultSts, update-indication-bit-position=-1
          signal VCU_APS2Position: start 104, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_APS2Position, update-indication-bit-position=-1
          signal VCU_EngineRunAllowFlg: start 112, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngineRunAllowFlg, update-indication-bit-position=-1
          signal VCU_EngineIdleSpeed: start 113, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngineIdleSpeed, update-indication-bit-position=-1
          signal VCU_EngineFuleCutoffReq: start 115, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EngineFuleCutoffReq, update-indication-bit-position=-1
          signal VCU_MCUSClutchPosition: start 116, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MCUSClutchPosition, update-indication-bit-position=-1
          signal VCU_MGCUWorkMode: start 118, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MGCUWorkMode, update-indication-bit-position=-1
          signal VCU_REChgTarget: start 120, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_REChgTarget, update-indication-bit-position=-1
          signal VCU_MotStartStopPowerUP: start 128, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MotStartStopPowerUP, update-indication-bit-position=-1
          signal VCU_MotStartStopPowerLOW: start 136, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MotStartStopPowerLOW, update-indication-bit-position=-1
          signal VCU_GCURequesSpeed_MGCU: start 144, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_GCURequesSpeed_MGCU, update-indication-bit-position=-1
          signal VCU_DynamicChgPwr: start 160, 5 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_DynamicChgPwr, update-indication-bit-position=-1
          signal VCU_ForceChgPwr: start 165, 5 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_ForceChgPwr, update-indication-bit-position=-1
          signal VCU_REStartType: start 170, 6 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_REStartType, update-indication-bit-position=-1
      frame VCU_0xBC: id 0xBC, from MVCU, frame-length=16, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu VCU_0xBC: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu VCU_0xBC: length=16, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=510, min=0}, i-signal-in-i-pdu=VCU_VehicleSpdDirect}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=3, min=0}, i-signal-in-i-pdu=VCU_ADM_ActualMode}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=3, min=0}, i-signal-in-i-pdu=VCU_ADM_MainMode}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_DeliveryModeSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_VehSpdLimtRemind}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_SinglePedalSts}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=VCU_GearLvrChangeSts}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=VCU_HighVoltSysSts}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=VCU_ChrgDischrgFunSts}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=VCU_CalibrationVersion}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=VCU_CalibrationNumber}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_VehicleNegTrqRspdSts}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=400, min=0}, i-signal-in-i-pdu=VCU_SlopeEst}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_SlopeEst_Valid}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=VCU_WheelTrqType}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_DriverAssistProhibitSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_VacumRlySts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_DriveSHVILSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_DriveMHVILSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_DCChgHVILSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_ACChgHVILSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_CCMHVILSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_SystemError}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=VCU_AccPedalFaultLV}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=VCU_HVILSysSts}
            {data-filter={data-filter-type=ALWAYS, max=254, min=0, offset=0}, i-signal-in-i-pdu=VCU_VacuumDegree}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_LPedalModeSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_LVSystemError}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_HVSystemError}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_OpeartingMode}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=VCU_EnergyMode}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_GearLevelPosFault}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_BrakeSwitchSts}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_SpdLimModeSts}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=VCU_TrqDstrbutnPrio}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=VCU_TrqDstrbutnTransferSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_MCUMDiffProtectSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_MCUSDiffProtectSts}
          signal VCU_VehicleSpdDirect: start 16, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_VehicleSpdDirect, update-indication-bit-position=-1
          signal VCU_ADM_ActualMode: start 112, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_ADM_ActualMode, update-indication-bit-position=-1
          signal VCU_ADM_MainMode: start 110, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_ADM_MainMode, update-indication-bit-position=-1
          signal VCU_DeliveryModeSts: start 25, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_DeliveryModeSts, update-indication-bit-position=-1
          signal VCU_VehSpdLimtRemind: start 26, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_VehSpdLimtRemind, update-indication-bit-position=-1
          signal VCU_SinglePedalSts: start 27, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_SinglePedalSts, update-indication-bit-position=-1
          signal VCU_GearLvrChangeSts: start 28, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_GearLvrChangeSts, update-indication-bit-position=-1
          signal VCU_HighVoltSysSts: start 32, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_HighVoltSysSts, update-indication-bit-position=-1
          signal VCU_ChrgDischrgFunSts: start 36, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_ChrgDischrgFunSts, update-indication-bit-position=-1
          signal VCU_CalibrationVersion: start 40, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_CalibrationVersion, update-indication-bit-position=-1
          signal VCU_CalibrationNumber: start 44, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_CalibrationNumber, update-indication-bit-position=-1
          signal VCU_VehicleNegTrqRspdSts: start 47, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_VehicleNegTrqRspdSts, update-indication-bit-position=-1
          signal VCU_SlopeEst: start 48, 10 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_SlopeEst, update-indication-bit-position=-1
          signal VCU_SlopeEst_Valid: start 58, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_SlopeEst_Valid, update-indication-bit-position=-1
          signal VCU_WheelTrqType: start 60, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_WheelTrqType, update-indication-bit-position=-1
          signal VCU_DriverAssistProhibitSts: start 64, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_DriverAssistProhibitSts, update-indication-bit-position=-1
          signal VCU_VacumRlySts: start 65, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_VacumRlySts, update-indication-bit-position=-1
          signal VCU_DriveSHVILSts: start 66, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_DriveSHVILSts, update-indication-bit-position=-1
          signal VCU_DriveMHVILSts: start 67, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_DriveMHVILSts, update-indication-bit-position=-1
          signal VCU_DCChgHVILSts: start 68, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_DCChgHVILSts, update-indication-bit-position=-1
          signal VCU_ACChgHVILSts: start 69, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_ACChgHVILSts, update-indication-bit-position=-1
          signal VCU_CCMHVILSts: start 70, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_CCMHVILSts, update-indication-bit-position=-1
          signal VCU_SystemError: start 71, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_SystemError, update-indication-bit-position=-1
          signal VCU_AccPedalFaultLV: start 72, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_AccPedalFaultLV, update-indication-bit-position=-1
          signal VCU_HVILSysSts: start 76, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_HVILSysSts, update-indication-bit-position=-1
          signal VCU_VacuumDegree: start 80, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_VacuumDegree, update-indication-bit-position=-1
          signal VCU_LPedalModeSts: start 88, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_LPedalModeSts, update-indication-bit-position=-1
          signal VCU_LVSystemError: start 90, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_LVSystemError, update-indication-bit-position=-1
          signal VCU_HVSystemError: start 91, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_HVSystemError, update-indication-bit-position=-1
          signal VCU_OpeartingMode: start 92, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_OpeartingMode, update-indication-bit-position=-1
          signal VCU_EnergyMode: start 94, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_EnergyMode, update-indication-bit-position=-1
          signal VCU_GearLevelPosFault: start 97, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_GearLevelPosFault, update-indication-bit-position=-1
          signal VCU_BrakeSwitchSts: start 98, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BrakeSwitchSts, update-indication-bit-position=-1
          signal VCU_SpdLimModeSts: start 100, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_SpdLimModeSts, update-indication-bit-position=-1
          signal VCU_TrqDstrbutnPrio: start 102, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_TrqDstrbutnPrio, update-indication-bit-position=-1
          signal VCU_TrqDstrbutnTransferSts: start 105, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_TrqDstrbutnTransferSts, update-indication-bit-position=-1
          signal VCU_MCUMDiffProtectSts: start 108, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MCUMDiffProtectSts, update-indication-bit-position=-1
          signal VCU_MCUSDiffProtectSts: start 109, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MCUSDiffProtectSts, update-indication-bit-position=-1
      frame VCU_0x1E5: id 0x1E5, from MVCU, frame-length=32, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu VCU_0x1E5: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu VCU_0x1E5: length=32
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=VCU_BCM_Authentication_MAC_A{0..15}}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=VCU_BCM_Authentication_Challenge_B{0..3}}
          signal VCU_BCM_Authentication_MAC_A0: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A0, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A1: start 8, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A1, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A2: start 16, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A2, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A3: start 24, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A3, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A4: start 32, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A4, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A5: start 40, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A5, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A6: start 48, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A6, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A7: start 56, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A7, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A8: start 64, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A8, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A9: start 72, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A9, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A10: start 80, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A10, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A11: start 88, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A11, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A12: start 96, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A12, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A13: start 104, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A13, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A14: start 112, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A14, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_MAC_A15: start 120, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_MAC_A15, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_Challenge_B0: start 128, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_Challenge_B0, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_Challenge_B1: start 136, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_Challenge_B1, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_Challenge_B2: start 144, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_Challenge_B2, update-indication-bit-position=-1
          signal VCU_BCM_Authentication_Challenge_B3: start 152, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BCM_Authentication_Challenge_B3, update-indication-bit-position=-1
      frame VCU_0xDE: id 0xDE, from MVCU, frame-length=32, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu VCU_0xDE: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu VCU_0xDE: length=32, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_BrkPedOpen}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_BrkPedClose}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_ColumnShiftP}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_VehiCrashSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_SleepSatisfiedSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_VehiHvCmd}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_GearQuitAps}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_REOverChgPwrFlag}
            {data-filter={data-filter-type=ALWAYS, max=256, min=0}, i-signal-in-i-pdu=VCU_VehiAccnFilt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=VCU_HvOffSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_ElecPwrBalanceReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_CDU_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_BMS_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_IVI_RecvTr}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0, offset=0}, i-signal-in-i-pdu=VCU_WheelMaxDrvTrq}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0, offset=0}, i-signal-in-i-pdu=VCU_WheelMaxRecTrq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_GCU_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_TCM_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_PTC_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_LossFctorFlgFL}
            {data-filter={data-filter-type=ALWAYS, max=127, min=0, offset=0}, i-signal-in-i-pdu=VCU_LowBattVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_HighPerforDisable}
            {data-filter={data-filter-type=ALWAYS, max=120, min=0, offset=0}, i-signal-in-i-pdu=VCU_AccPedHSigVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_LossFctorFlgFR}
            {data-filter={data-filter-type=ALWAYS, max=120, min=0, offset=0}, i-signal-in-i-pdu=VCU_AccPedLSigVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_LossFctorFlgRL}
            {data-filter={data-filter-type=ALWAYS, max=120, min=0, offset=0}, i-signal-in-i-pdu=VCU_AccPedHPwrVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_LossFctorFlgRR}
            {data-filter={data-filter-type=ALWAYS, max=120, min=0, offset=0}, i-signal-in-i-pdu=VCU_AccPedLPwrVolt}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=VCU_PreReqChgPwr}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=VCU_VehPwrChageLimit}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=VCU_FastPwrRequest}
            {data-filter={data-filter-type=ALWAYS, max=200, min=0, offset=0}, i-signal-in-i-pdu=VCU_On2KL15_Volt}
            {data-filter={data-filter-type=ALWAYS, max=31, min=0, offset=0}, i-signal-in-i-pdu=VCU_ClutchWrkModDebug}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_HighPerforSwtFlg}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=7000, min=0}, i-signal-in-i-pdu=VCU_VehiPowrConsumption}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=VCU_MDrvFilterTrqRange}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=VCU_WheelPwrOvrLimitflgRE}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_MRDrvControlMode}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_MRDrvControlModeVD}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_VehicleDirectMR}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_VehicleDirectMRVD}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0}, i-signal-in-i-pdu=VCU_MRDrvRequestTorque}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=34000, min=0}, i-signal-in-i-pdu=VCU_MRDrvRequesSpeed}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=510, min=0, offset=0}, i-signal-in-i-pdu=VCU_MCUMRMaxDischargePower}
            {data-filter={data-filter-type=ALWAYS, max=50, min=0, offset=0}, i-signal-in-i-pdu=VCU_MCUMRMaxPosDampgTrq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_MRDrvRequestTorqueVD}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=510, min=0, offset=0}, i-signal-in-i-pdu=VCU_MCUMRMaxChargePower}
            {data-filter={data-filter-type=ALWAYS, max=50, min=0}, i-signal-in-i-pdu=VCU_MCUMRMaxNegDampgTrq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_MRDrvRequesSpeedVD}
            {data-filter={data-filter-type=ALWAYS, max=100, min=0, offset=0}, i-signal-in-i-pdu=VCU_MCUMRDampgLmtFactor}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VCU_SuppressJitterMCUMRRequest}
          signal VCU_BrkPedOpen: start 0, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BrkPedOpen, update-indication-bit-position=-1  # 制动踏板常开信号状态"
          signal VCU_BrkPedClose: start 1, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BrkPedClose, update-indication-bit-position=-1  # 制动踏板常闭信号状态"
          signal VCU_ColumnShiftP: start 2, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_ColumnShiftP, update-indication-bit-position=-1  # P档硬线信号状态"
          signal VCU_VehiCrashSts: start 3, 1 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 碰撞状态"
          signal VCU_SleepSatisfiedSts: start 4, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_SleepSatisfiedSts, update-indication-bit-position=-1  # 休眠允许状态(VCU)"
          signal VCU_VehiHvCmd: start 5, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_VehiHvCmd, update-indication-bit-position=-1  # 高压启动命令"
          signal VCU_GearQuitAps: start 6, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_GearQuitAps, update-indication-bit-position=-1  # 操作挡杆退出APS指令"
          signal VCU_REOverChgPwrFlag: start 7, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_REOverChgPwrFlag, update-indication-bit-position=-1  # 增程超功率标志位"
          signal VCU_VehiAccnFilt: start 8, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 驱动加速度(内部计算)"
          signal VCU_HvOffSts: start 16, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_HvOffSts, update-indication-bit-position=-1  # 高压下电状态"
          signal VCU_ElecPwrBalanceReq: start 20, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_ElecPwrBalanceReq, update-indication-bit-position=-1  # 电平衡积分满足标志位"
          signal VCU_CDU_RecvTr: start 21, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_CDU_RecvTr, update-indication-bit-position=-1  # DCDC报文接收标志位"
          signal VCU_BMS_RecvTr: start 22, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_BMS_RecvTr, update-indication-bit-position=-1  # BMS报文接收标志位"
          signal VCU_IVI_RecvTr: start 23, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_IVI_RecvTr, update-indication-bit-position=-1  # IVI报文接收标志位"
          signal VCU_WheelMaxDrvTrq: start 24, 10 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_WheelMaxDrvTrq, update-indication-bit-position=-1  # 最大轮端驱动扭矩限制值"
          signal VCU_WheelMaxRecTrq: start 34, 10 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_WheelMaxRecTrq, update-indication-bit-position=-1  # 最大轮端回收扭矩限制值"
          signal VCU_GCU_RecvTr: start 44, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_GCU_RecvTr, update-indication-bit-position=-1  # GCU报文接收标志位"
          signal VCU_TCM_RecvTr: start 45, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_TCM_RecvTr, update-indication-bit-position=-1  # TCM报文接收标志位"
          signal VCU_PTC_RecvTr: start 46, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_PTC_RecvTr, update-indication-bit-position=-1  # PTC报文接收标志位"
          signal VCU_LossFctorFlgFL: start 47, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_LossFctorFlgFL, update-indication-bit-position=-1  # 左前车辆打滑状态判断标志位"
          signal VCU_LowBattVolt: start 48, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_LowBattVolt, update-indication-bit-position=-1  # 电源电压值"
          signal VCU_HighPerforDisable: start 55, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_HighPerforDisable, update-indication-bit-position=-1  # 动力优先退出状态"
          signal VCU_AccPedHSigVolt: start 56, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_AccPedHSigVolt, update-indication-bit-position=-1  # 加速踏板信号(高)电压值"
          signal VCU_LossFctorFlgFR: start 63, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_LossFctorFlgFR, update-indication-bit-position=-1  # 右前车辆打滑状态判断标志位"
          signal VCU_AccPedLSigVolt: start 64, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_AccPedLSigVolt, update-indication-bit-position=-1  # 加速踏板信号(低)电压值"
          signal VCU_LossFctorFlgRL: start 71, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_LossFctorFlgRL, update-indication-bit-position=-1  # 左后车辆打滑状态判断标志位"
          signal VCU_AccPedHPwrVolt: start 72, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_AccPedHPwrVolt, update-indication-bit-position=-1  # 加速踏板电源(高)电压值"
          signal VCU_LossFctorFlgRR: start 79, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_LossFctorFlgRR, update-indication-bit-position=-1  # 右后车辆打滑状态判断标志位"
          signal VCU_AccPedLPwrVolt: start 80, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_AccPedLPwrVolt, update-indication-bit-position=-1  # 加速踏板电源(低)电压值"
          signal VCU_PreReqChgPwr: start 88, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_PreReqChgPwr, update-indication-bit-position=-1  # 整车回收功率"
          signal VCU_VehPwrChageLimit: start 96, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_VehPwrChageLimit, update-indication-bit-position=-1  # 整车充电功率限制"
          signal VCU_FastPwrRequest: start 104, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_FastPwrRequest, update-indication-bit-position=-1  # BMS快速降扭请求扭矩"
          signal VCU_On2KL15_Volt: start 112, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_On2KL15_Volt, update-indication-bit-position=-1  # ON2A硬线电压"
          signal VCU_ClutchWrkModDebug: start 120, 5 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_ClutchWrkModDebug, update-indication-bit-position=-1  # ON2A硬线电压"
          signal VCU_HighPerforSwtFlg: start 127, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_HighPerforSwtFlg, update-indication-bit-position=-1  # 动力优先退出功率切换标志"
          signal VCU_VehiPowrConsumption: start 128, 13 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_VehiPowrConsumption, update-indication-bit-position=-1  # 电平衡积分"
          signal VCU_MDrvFilterTrqRange: start 141, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MDrvFilterTrqRange, update-indication-bit-position=-1  # 主电机过零扭矩状态"
          signal VCU_WheelPwrOvrLimitflgRE: start 125, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_WheelPwrOvrLimitflgRE, update-indication-bit-position=-1  # 增程配置超功率标志位"
          signal VCU_MRDrvControlMode: start 155, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MRDrvControlMode, update-indication-bit-position=-1  # 主（右）电机转速扭矩控制选择位"
          signal VCU_MRDrvControlModeVD: start 156, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MRDrvControlModeVD, update-indication-bit-position=-1  # 主（右）电机转速扭矩控制选择位有效性"
          signal VCU_VehicleDirectMR: start 157, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_VehicleDirectMR, update-indication-bit-position=-1  # 车辆方向主轴右电机"
          signal VCU_VehicleDirectMRVD: start 158, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_VehicleDirectMRVD, update-indication-bit-position=-1  # 车辆方向有效性主轴右电机"
          signal VCU_MRDrvRequestTorque: start 160, 16 bit, little-endian, init-value=5000, base-type=uint16, implementation-data-type=DT_VCU_MRDrvRequestTorque, update-indication-bit-position=-1  # 主（右）电机扭矩控制值"
          signal VCU_MRDrvRequesSpeed: start 176, 16 bit, little-endian, init-value=17000, base-type=uint16, implementation-data-type=DT_VCU_MRDrvRequesSpeed, update-indication-bit-position=-1  # 主（右）电机转速控制"
          signal VCU_MCUMRMaxDischargePower: start 192, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_MCUMRMaxDischargePower, update-indication-bit-position=-1  # 主（右）电机最大允许放电功率"
          signal VCU_MCUMRMaxPosDampgTrq: start 201, 6 bit, little-endian, init-value=50, base-type=uint8, implementation-data-type=DT_VCU_MCUMRMaxPosDampgTrq, update-indication-bit-position=-1  # 主驱（右）最大允许抑抖补偿正扭"
          signal VCU_MRDrvRequestTorqueVD: start 207, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MRDrvRequestTorqueVD, update-indication-bit-position=-1  # 主（右）电机扭矩控制值有效性"
          signal VCU_MCUMRMaxChargePower: start 208, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_VCU_MCUMRMaxChargePower, update-indication-bit-position=-1  # 主（右）电机最大允许充电功率"
          signal VCU_MCUMRMaxNegDampgTrq: start 217, 6 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MCUMRMaxNegDampgTrq, update-indication-bit-position=-1  # 主驱（右）最大允许抑抖补偿负扭"
          signal VCU_MRDrvRequesSpeedVD: start 223, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MRDrvRequesSpeedVD, update-indication-bit-position=-1  # 主（右）电机转速控制有效性"
          signal VCU_MCUMRDampgLmtFactor: start 224, 7 bit, little-endian, init-value=100, base-type=uint8, implementation-data-type=DT_VCU_MCUMRDampgLmtFactor, update-indication-bit-position=-1  # 主（右）驱抑抖限制系数"
          signal VCU_SuppressJitterMCUMRRequest: start 231, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_SuppressJitterMCUMRRequest, update-indication-bit-position=-1  # 关闭主（右）电机抑制抖动"
      frame VCU_0x3: id 0xDE, from MVCU, frame-length=32, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu VCU_0x3: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu VCU_0x3: length=32, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_BrkPedOpen}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_BrkPedClose}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_ColumnShiftP}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_VehiCrashSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_SleepSatisfiedSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_VehiHvCmd}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_GearQuitAps}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_REOverChgPwrFlag}
            {data-filter={data-filter-type=ALWAYS, max=256, min=0}, i-signal-in-i-pdu=EOL_VCU_VehiAccnFilt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_HvOffSts}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_ElecPwrBalanceReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_CDU_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_BMS_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_IVI_RecvTr}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_WheelMaxDrvTrq}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_WheelMaxRecTrq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_GCU_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_TCM_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_PTC_RecvTr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_LossFctorFlgFL}
            {data-filter={data-filter-type=ALWAYS, max=127, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_LowBattVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_HighPerforDisable}
            {data-filter={data-filter-type=ALWAYS, max=120, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_AccPedHSigVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_LossFctorFlgFR}
            {data-filter={data-filter-type=ALWAYS, max=120, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_AccPedLSigVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_LossFctorFlgRL}
            {data-filter={data-filter-type=ALWAYS, max=120, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_AccPedHPwrVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_LossFctorFlgRR}
            {data-filter={data-filter-type=ALWAYS, max=120, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_AccPedLPwrVolt}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_PreReqChgPwr}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_VehPwrChageLimit}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_FastPwrRequest}
            {data-filter={data-filter-type=ALWAYS, max=200, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_On2KL15_Volt}
            {data-filter={data-filter-type=ALWAYS, max=31, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_ClutchWrkModDebug}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_HighPerforSwtFlg}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=7000, min=0}, i-signal-in-i-pdu=EOL_VCU_VehiPowrConsumption}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_MDrvFilterTrqRange}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_WheelPwrOvrLimitflgRE}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_MRDrvControlMode}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_MRDrvControlModeVD}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_VehicleDirectMR}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_VehicleDirectMRVD}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0}, i-signal-in-i-pdu=EOL_VCU_MRDrvRequestTorque}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=34000, min=0}, i-signal-in-i-pdu=EOL_VCU_MRDrvRequesSpeed}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=510, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_MCUMRMaxDischargePower}
            {data-filter={data-filter-type=ALWAYS, max=50, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_MCUMRMaxPosDampgTrq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_MRDrvRequestTorqueVD}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=510, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_MCUMRMaxChargePower}
            {data-filter={data-filter-type=ALWAYS, max=50, min=0}, i-signal-in-i-pdu=EOL_VCU_MCUMRMaxNegDampgTrq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_MRDrvRequesSpeedVD}
            {data-filter={data-filter-type=ALWAYS, max=100, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_MCUMRDampgLmtFactor}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=EOL_VCU_SuppressJitterMCUMRRequest}
          signal EOL_VCU_BrkPedOpen: start 0, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_BrkPedOpen, update-indication-bit-position=-1  # 制动踏板常开信号状态"
          signal EOL_VCU_BrkPedClose: start 1, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_BrkPedClose, update-indication-bit-position=-1  # 制动踏板常闭信号状态"
          signal EOL_VCU_ColumnShiftP: start 2, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_ColumnShiftP, update-indication-bit-position=-1  # P档硬线信号状态"
          signal EOL_VCU_VehiCrashSts: start 3, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_VehiCrashSts, update-indication-bit-position=-1  # 碰撞状态"
          signal EOL_VCU_SleepSatisfiedSts: start 4, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_SleepSatisfiedSts, update-indication-bit-position=-1  # 休眠允许状态(VCU)"
          signal EOL_VCU_VehiHvCmd: start 5, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_VehiHvCmd, update-indication-bit-position=-1  # 高压启动命令"
          signal EOL_VCU_GearQuitAps: start 6, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_GearQuitAps, update-indication-bit-position=-1  # 操作挡杆退出APS指令"
          signal EOL_VCU_REOverChgPwrFlag: start 7, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_REOverChgPwrFlag, update-indication-bit-position=-1  # 增程超功率标志位"
          signal EOL_VCU_VehiAccnFilt: start 8, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 驱动加速度(内部计算)"
          signal EOL_VCU_HvOffSts: start 16, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_HvOffSts, update-indication-bit-position=-1  # 高压下电状态"
          signal EOL_VCU_ElecPwrBalanceReq: start 20, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_ElecPwrBalanceReq, update-indication-bit-position=-1  # 电平衡积分满足标志位"
          signal EOL_VCU_CDU_RecvTr: start 21, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_CDU_RecvTr, update-indication-bit-position=-1  # DCDC报文接收标志位"
          signal EOL_VCU_BMS_RecvTr: start 22, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_BMS_RecvTr, update-indication-bit-position=-1  # BMS报文接收标志位"
          signal EOL_VCU_IVI_RecvTr: start 23, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_IVI_RecvTr, update-indication-bit-position=-1  # IVI报文接收标志位"
          signal EOL_VCU_WheelMaxDrvTrq: start 24, 10 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_EOL_VCU_WheelMaxDrvTrq, update-indication-bit-position=-1  # 最大轮端驱动扭矩限制值"
          signal EOL_VCU_WheelMaxRecTrq: start 34, 10 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_EOL_VCU_WheelMaxRecTrq, update-indication-bit-position=-1  # 最大轮端回收扭矩限制值"
          signal EOL_VCU_GCU_RecvTr: start 44, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_GCU_RecvTr, update-indication-bit-position=-1  # GCU报文接收标志位"
          signal EOL_VCU_TCM_RecvTr: start 45, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_TCM_RecvTr, update-indication-bit-position=-1  # TCM报文接收标志位"
          signal EOL_VCU_PTC_RecvTr: start 46, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_PTC_RecvTr, update-indication-bit-position=-1  # PTC报文接收标志位"
          signal EOL_VCU_LossFctorFlgFL: start 47, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_LossFctorFlgFL, update-indication-bit-position=-1  # 左前车辆打滑状态判断标志位"
          signal EOL_VCU_LowBattVolt: start 48, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_LowBattVolt, update-indication-bit-position=-1  # 电源电压值"
          signal EOL_VCU_HighPerforDisable: start 55, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_HighPerforDisable, update-indication-bit-position=-1  # 动力优先退出状态"
          signal EOL_VCU_AccPedHSigVolt: start 56, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_AccPedHSigVolt, update-indication-bit-position=-1  # 加速踏板信号(高)电压值"
          signal EOL_VCU_LossFctorFlgFR: start 63, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_LossFctorFlgFR, update-indication-bit-position=-1  # 右前车辆打滑状态判断标志位"
          signal EOL_VCU_AccPedLSigVolt: start 64, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_AccPedLSigVolt, update-indication-bit-position=-1  # 加速踏板信号(低)电压值"
          signal EOL_VCU_LossFctorFlgRL: start 71, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_LossFctorFlgRL, update-indication-bit-position=-1  # 左后车辆打滑状态判断标志位"
          signal EOL_VCU_AccPedHPwrVolt: start 72, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_AccPedHPwrVolt, update-indication-bit-position=-1  # 加速踏板电源(高)电压值"
          signal EOL_VCU_LossFctorFlgRR: start 79, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_LossFctorFlgRR, update-indication-bit-position=-1  # 右后车辆打滑状态判断标志位"
          signal EOL_VCU_AccPedLPwrVolt: start 80, 7 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_AccPedLPwrVolt, update-indication-bit-position=-1  # 加速踏板电源(低)电压值"
          signal EOL_VCU_PreReqChgPwr: start 88, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_PreReqChgPwr, update-indication-bit-position=-1  # 整车回收功率"
          signal EOL_VCU_VehPwrChageLimit: start 96, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_VehPwrChageLimit, update-indication-bit-position=-1  # 整车充电功率限制"
          signal EOL_VCU_FastPwrRequest: start 104, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_FastPwrRequest, update-indication-bit-position=-1  # BMS快速降扭请求扭矩"
          signal EOL_VCU_On2KL15_Volt: start 112, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_On2KL15_Volt, update-indication-bit-position=-1  # ON2A硬线电压"
          signal EOL_VCU_ClutchWrkModDebug: start 120, 5 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_ClutchWrkModDebug, update-indication-bit-position=-1  # ON2A硬线电压"
          signal EOL_VCU_HighPerforSwtFlg: start 127, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_HighPerforSwtFlg, update-indication-bit-position=-1  # 动力优先退出功率切换标志"
          signal EOL_VCU_VehiPowrConsumption: start 128, 13 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_EOL_VCU_VehiPowrConsumption, update-indication-bit-position=-1  # 电平衡积分"
          signal EOL_VCU_MDrvFilterTrqRange: start 141, 3 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_MDrvFilterTrqRange, update-indication-bit-position=-1  # 主电机过零扭矩状态"
          signal EOL_VCU_WheelPwrOvrLimitflgRE: start 125, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_WheelPwrOvrLimitflgRE, update-indication-bit-position=-1  # 增程配置超功率标志位"
          signal EOL_VCU_MRDrvControlMode: start 155, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_MRDrvControlMode, update-indication-bit-position=-1  # 主（右）电机转速扭矩控制选择位"
          signal EOL_VCU_MRDrvControlModeVD: start 156, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_MRDrvControlModeVD, update-indication-bit-position=-1  # 主（右）电机转速扭矩控制选择位有效性"
          signal EOL_VCU_VehicleDirectMR: start 157, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_VehicleDirectMR, update-indication-bit-position=-1  # 车辆方向主轴右电机"
          signal EOL_VCU_VehicleDirectMRVD: start 158, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_VehicleDirectMRVD, update-indication-bit-position=-1  # 车辆方向有效性主轴右电机"
          signal EOL_VCU_MRDrvRequestTorque: start 160, 16 bit, little-endian, init-value=5000, base-type=uint16, implementation-data-type=DT_EOL_VCU_MRDrvRequestTorque, update-indication-bit-position=-1  # 主（右）电机扭矩控制值"
          signal EOL_VCU_MRDrvRequesSpeed: start 176, 16 bit, little-endian, init-value=17000, base-type=uint16, implementation-data-type=DT_EOL_VCU_MRDrvRequesSpeed, update-indication-bit-position=-1  # 主（右）电机转速控制"
          signal EOL_VCU_MCUMRMaxDischargePower: start 192, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_EOL_VCU_MCUMRMaxDischargePower, update-indication-bit-position=-1  # 主（右）电机最大允许放电功率"
          signal EOL_VCU_MCUMRMaxPosDampgTrq: start 201, 6 bit, little-endian, init-value=50, base-type=uint8, implementation-data-type=DT_EOL_VCU_MCUMRMaxPosDampgTrq, update-indication-bit-position=-1  # 主驱（右）最大允许抑抖补偿正扭"
          signal EOL_VCU_MRDrvRequestTorqueVD: start 207, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_MRDrvRequestTorqueVD, update-indication-bit-position=-1  # 主（右）电机扭矩控制值有效性"
          signal EOL_VCU_MCUMRMaxChargePower: start 208, 9 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_EOL_VCU_MCUMRMaxChargePower, update-indication-bit-position=-1  # 主（右）电机最大允许充电功率"
          signal EOL_VCU_MCUMRMaxNegDampgTrq: start 217, 6 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_MCUMRMaxNegDampgTrq, update-indication-bit-position=-1  # 主驱（右）最大允许抑抖补偿负扭"
          signal EOL_VCU_MRDrvRequesSpeedVD: start 223, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_MRDrvRequesSpeedVD, update-indication-bit-position=-1  # 主（右）电机转速控制有效性"
          signal EOL_VCU_MCUMRDampgLmtFactor: start 224, 7 bit, little-endian, init-value=100, base-type=uint8, implementation-data-type=DT_EOL_VCU_MCUMRDampgLmtFactor, update-indication-bit-position=-1  # 主（右）驱抑抖限制系数"
          signal EOL_VCU_SuppressJitterMCUMRRequest: start 231, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_EOL_VCU_SuppressJitterMCUMRRequest, update-indication-bit-position=-1  # 关闭主（右）电机抑制抖动"
      frame ICU_0xDF: id 0xDF, to MVCU, frame-length=16, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu ICU_0xDF: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu ICU_0xDF: length=16
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=ICU_CRC_DF}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=ICU_RollingCounter_DF}
            {data-filter={data-filter-type=ALWAYS, max=65535, min=0, offset=0}, i-signal-in-i-pdu=ICU_IMU_ACC_x}
            {data-filter={data-filter-type=ALWAYS, max=65535, min=0, offset=0}, i-signal-in-i-pdu=ICU_IMU_ACC_y}
            {data-filter={data-filter-type=ALWAYS, max=65535, min=0, offset=0}, i-signal-in-i-pdu=ICU_IMU_ACC_z}
            {data-filter={data-filter-type=ALWAYS, max=65535, min=0, offset=0}, i-signal-in-i-pdu=ICU_IMU_ACC_Roll_Rate}
            {data-filter={data-filter-type=ALWAYS, max=65535, min=0, offset=0}, i-signal-in-i-pdu=ICU_IMU_ACC_Pitch_Rate}
            {data-filter={data-filter-type=ALWAYS, max=65535, min=0, offset=0}, i-signal-in-i-pdu=ICU_IMU_ACC_Yaw_Rate}
            {data-filter={data-filter-type=ALWAYS, max=2, min=0, offset=0}, i-signal-in-i-pdu=ICU_IMU_Calibrated}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=ICU_IMU_Valid}
          signal ICU_CRC_DF: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_ICU_CRC_DF, update-indication-bit-position=-1, to MVCU
          signal ICU_RollingCounter_DF: start 8, 4 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_ICU_RollingCounter_DF, update-indication-bit-position=-1, to MVCU
          signal ICU_IMU_ACC_x: start 16, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_ICU_IMU_ACC_x, update-indication-bit-position=-1, to MVCU
          signal ICU_IMU_ACC_y: start 32, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_ICU_IMU_ACC_y, update-indication-bit-position=-1, to MVCU
          signal ICU_IMU_ACC_z: start 48, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_ICU_IMU_ACC_z, update-indication-bit-position=-1, to MVCU
          signal ICU_IMU_ACC_Roll_Rate: start 64, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_ICU_IMU_ACC_Roll_Rate, update-indication-bit-position=-1, to MVCU
          signal ICU_IMU_ACC_Pitch_Rate: start 80, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_ICU_IMU_ACC_Pitch_Rate, update-indication-bit-position=-1, to MVCU
          signal ICU_IMU_ACC_Yaw_Rate: start 96, 16 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_ICU_IMU_ACC_Yaw_Rate, update-indication-bit-position=-1, to MVCU
          signal ICU_IMU_Calibrated: start 112, 2 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_ICU_IMU_Calibrated, update-indication-bit-position=-1, to MVCU
          signal ICU_IMU_Valid: start 114, 1 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_ICU_IMU_Valid, update-indication-bit-position=-1, to MVCU
      frame MCUM_0x5D0: id 0x5D0, from MVCU, frame-length=16, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu MCUM_0x5D0: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu MCUM_0x5D0: length=32, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.02}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.02}
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_Id_Ref}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_Iq_Ref}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_Id_Fb}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_Iq_Fb}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_Torque_Ref}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_R_Id_Ref}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_R_Iq_Ref}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_R_Id_Fb}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_R_Iq_Fb}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_R_Torque_Ref}
          signal MCUM_Id_Ref: start 0, 11 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Id_Ref, update-indication-bit-position=-1
          signal MCUM_Iq_Ref: start 11, 11 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Iq_Ref, update-indication-bit-position=-1
          signal MCUM_Id_Fb: start 22, 11 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Id_Fb, update-indication-bit-position=-1
          signal MCUM_Iq_Fb: start 33, 11 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Iq_Fb, update-indication-bit-position=-1
          signal MCUM_Torque_Ref: start 44, 10 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_Torque_Ref, update-indication-bit-position=-1
          signal MCUM_R_Id_Ref: start 64, 11 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_R_Id_Ref, update-indication-bit-position=-1
          signal MCUM_R_Iq_Ref: start 75, 11 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_R_Iq_Ref, update-indication-bit-position=-1
          signal MCUM_R_Id_Fb: start 86, 11 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_R_Id_Fb, update-indication-bit-position=-1
          signal MCUM_R_Iq_Fb: start 97, 11 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_R_Iq_Fb, update-indication-bit-position=-1
          signal MCUM_R_Torque_Ref: start 108, 10 bit, little-endian, init-value=0, base-type=uint16, implementation-data-type=DT_MCUM_R_Torque_Ref, update-indication-bit-position=-1
      frame MCUM_0x5D1: id 0x5D1, from MVCU, frame-length=64, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu MCUM_0x5D1: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu MCUM_0x5D1: length=64, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.05}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.05}
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_Vd_Ref}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_Vq_Ref}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_Id_LookUp}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_Iq_LookUp}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=MCUM_Spd_Delta}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Us_Out}
            {data-filter={data-filter-type=ALWAYS, max=127, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Torque_PwrEst}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_UserDefine_50ms}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Torque_ExtChar}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_Damp_CompTorque}
            {data-filter={data-filter-type=ALWAYS, max=100, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Damp_CompCoeff}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_Damp_State}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=MCUM_PWM_State}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_JuncTemp_Max}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=8000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_JuncLoss_Max}
            {data-filter={data-filter-type=ALWAYS, max=200, min=0}, i-signal-in-i-pdu=MCUM_CurrAmp_Comp}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0}, i-signal-in-i-pdu=MCUM_CurrTheta_Comp}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=MCUM_RawSinCorr}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=MCUM_RawCosCorr}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=17000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_LUT_Spd}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HighVoltPowerOffReq}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0}, i-signal-in-i-pdu=MCUM_R_MaxTorqueAllow}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=34000, min=0}, i-signal-in-i-pdu=MCUM_R_MaxSpeedAllow}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0}, i-signal-in-i-pdu=MCUM_R_MinTorqueAllow}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_R_MotorTemp}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_R_IGBTTemp}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_R_InletTemp}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HeatPwrAllwd}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HeatFdBck}
            {data-filter={data-filter-type=ALWAYS, max=128, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HeatPwrAct}
            {data-filter={data-filter-type=ALWAYS, max=128, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HeatPwrMax}
            {data-filter={data-filter-type=ALWAYS, max=31, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HeatPwrAval}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_R_Vd_Ref}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_R_Vq_Ref}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_R_Id_LookUp}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0}, i-signal-in-i-pdu=MCUM_R_Iq_LookUp}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=MCUM_R_Spd_Delta}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Us_Out}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_R_Torque_PwrEst}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_R_UserDefine_50ms}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Torque_ExtChar}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0}, i-signal-in-i-pdu=MCUM_R_Damp_CompTorque}
            {data-filter={data-filter-type=ALWAYS, max=100, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Damp_CompCoeff}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Damp_State}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_PWM_State}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_JuncTemp_Max}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=8000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_JuncLoss_Max}
            {data-filter={data-filter-type=ALWAYS, max=200, min=0}, i-signal-in-i-pdu=MCUM_R_CurrAmp_Comp}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0}, i-signal-in-i-pdu=MCUM_R_CurrTheta_Comp}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=MCUM_R_RawSinCorr}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=MCUM_R_RawCosCorr}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=17000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_LUT_Spd}
          signal MCUM_Vd_Ref: start 0, 10 bit, little-endian, init-value=500.0, base-type=uint16, implementation-data-type=DT_MCUM_Vd_Ref, update-indication-bit-position=-1  # 主电机D轴电压"
          signal MCUM_Vq_Ref: start 10, 10 bit, little-endian, init-value=500.0, base-type=uint16, implementation-data-type=DT_MCUM_Vq_Ref, update-indication-bit-position=-1  # 主电机Q轴电压"
          signal MCUM_Id_LookUp: start 20, 11 bit, little-endian, init-value=1000.0, base-type=uint16, implementation-data-type=DT_MCUM_Id_LookUp, update-indication-bit-position=-1  # 主电机D轴查表电流给定"
          signal MCUM_Iq_LookUp: start 31, 11 bit, little-endian, init-value=1000.0, base-type=uint16, implementation-data-type=DT_MCUM_Iq_LookUp, update-indication-bit-position=-1  # 主电机Q轴查表电流给定"
          signal MCUM_Spd_Delta: start 42, 12 bit, little-endian, init-value=2000.0, base-type=uint16, implementation-data-type=DT_MCUM_Spd_Delta, update-indication-bit-position=-1  # 弱磁转折转速调节值"
          signal MCUM_Us_Out: start 54, 11 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_Us_Out, update-indication-bit-position=-1  # 主电机Us输出"
          signal MCUM_Torque_PwrEst: start 65, 7 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_Torque_PwrEst, update-indication-bit-position=-1  # 主电机功率法估算转矩"
          signal MCUM_UserDefine_50ms: start 72, 10 bit, little-endian, init-value=500.0, base-type=uint16, implementation-data-type=DT_MCUM_UserDefine_50ms, update-indication-bit-position=-1  # 主电机用户自定义_50ms"
          signal MCUM_Torque_ExtChar: start 82, 9 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_Torque_ExtChar, update-indication-bit-position=-1  # 主电机外特性扭矩"
          signal MCUM_Damp_CompTorque: start 91, 10 bit, little-endian, init-value=500.0, base-type=uint16, implementation-data-type=DT_MCUM_Damp_CompTorque, update-indication-bit-position=-1  # 主电机防抖补偿转矩"
          signal MCUM_Damp_CompCoeff: start 101, 7 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_Damp_CompCoeff, update-indication-bit-position=-1  # 主电机防抖补偿系数"
          signal MCUM_Damp_State: start 108, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_Damp_State, update-indication-bit-position=-1  # 主电机防抖状态"
          signal MCUM_PWM_State: start 109, 2 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_PWM_State, update-indication-bit-position=-1  # 主电机PWM状态"
          signal MCUM_JuncTemp_Max: start 111, 12 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_JuncTemp_Max, update-indication-bit-position=-1  # 主电机最高结温 "
          signal MCUM_JuncLoss_Max: start 123, 13 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_JuncLoss_Max, update-indication-bit-position=-1  # 主电机控制器最高估算损耗"
          signal MCUM_CurrAmp_Comp: start 136, 8 bit, little-endian, init-value=100.0, base-type=uint8, implementation-data-type=DT_MCUM_CurrAmp_Comp, update-indication-bit-position=-1  # 主电机电流幅值补偿值"
          signal MCUM_CurrTheta_Comp: start 144, 9 bit, little-endian, init-value=250.0, base-type=uint16, implementation-data-type=DT_MCUM_CurrTheta_Comp, update-indication-bit-position=-1  # 主电机电流角度补偿值"
          signal MCUM_RawSinCorr: start 153, 12 bit, little-endian, init-value=2000.0, base-type=uint16, implementation-data-type=DT_MCUM_RawSinCorr, update-indication-bit-position=-1  # 主电机原始电涡流Sin信号"
          signal MCUM_RawCosCorr: start 165, 12 bit, little-endian, init-value=2000.0, base-type=uint16, implementation-data-type=DT_MCUM_RawCosCorr, update-indication-bit-position=-1  # 主电机原始电涡流Cos信号"
          signal MCUM_LUT_Spd: start 177, 15 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_LUT_Spd, update-indication-bit-position=-1  # 查表转速"
          signal MCUM_R_HighVoltPowerOffReq: start 192, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HighVoltPowerOffReq, update-indication-bit-position=-1  # 主右电机下高压请求"
          signal MCUM_R_MaxTorqueAllow: start 193, 16 bit, little-endian, init-value=55000.0, base-type=uint16, implementation-data-type=DT_MCUM_R_MaxTorqueAllow, update-indication-bit-position=-1  # 主右电机最大允许扭矩"
          signal MCUM_R_MaxSpeedAllow: start 209, 16 bit, little-endian, init-value=34000.0, base-type=uint16, implementation-data-type=DT_MCUM_R_MaxSpeedAllow, update-indication-bit-position=-1  # 主右电机最大允许转速"
          signal MCUM_R_MinTorqueAllow: start 225, 16 bit, little-endian, init-value=55000.0, base-type=uint16, implementation-data-type=DT_MCUM_R_MinTorqueAllow, update-indication-bit-position=-1  # 主右电机最小允许扭矩"
          signal MCUM_R_MotorTemp: start 241, 8 bit, little-endian, init-value=100.0, base-type=uint8, implementation-data-type=DT_MCUM_R_MotorTemp, update-indication-bit-position=-1  # 主右电机温度"
          signal MCUM_R_IGBTTemp: start 249, 8 bit, little-endian, init-value=100.0, base-type=uint8, implementation-data-type=DT_MCUM_R_IGBTTemp, update-indication-bit-position=-1  # 主右电机IGBT温度"
          signal MCUM_R_InletTemp: start 257, 8 bit, little-endian, init-value=100.0, base-type=uint8, implementation-data-type=DT_MCUM_R_InletTemp, update-indication-bit-position=-1  # 主右电机进水口温度"
          signal MCUM_R_HeatPwrAllwd: start 265, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HeatPwrAllwd, update-indication-bit-position=-1  # 主右电机主动加热允许"
          signal MCUM_R_HeatFdBck: start 266, 2 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HeatFdBck, update-indication-bit-position=-1  # 主右电机主动加热状态反馈"
          signal MCUM_R_HeatPwrAct: start 268, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HeatPwrAct, update-indication-bit-position=-1  # 主右电机电驱系统加热功率"
          signal MCUM_R_HeatPwrMax: start 276, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HeatPwrMax, update-indication-bit-position=-1  # 主右电机最大允许加热功率"
          signal MCUM_R_HeatPwrAval: start 284, 5 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HeatPwrAval, update-indication-bit-position=-1  # 主右电机可用发热功率"
          signal MCUM_R_Vd_Ref: start 289, 10 bit, little-endian, init-value=500.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Vd_Ref, update-indication-bit-position=-1  # 主右电机D轴电压"
          signal MCUM_R_Vq_Ref: start 299, 10 bit, little-endian, init-value=500.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Vq_Ref, update-indication-bit-position=-1  # 主右电机Q轴电压"
          signal MCUM_R_Id_LookUp: start 309, 11 bit, little-endian, init-value=1000.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Id_LookUp, update-indication-bit-position=-1  # 主右电机D轴查表电流给定"
          signal MCUM_R_Iq_LookUp: start 320, 11 bit, little-endian, init-value=1000.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Iq_LookUp, update-indication-bit-position=-1  # 主右电机Q轴查表电流给定"
          signal MCUM_R_Spd_Delta: start 331, 12 bit, little-endian, init-value=2000.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Spd_Delta, update-indication-bit-position=-1  # 主右电机弱磁转折转速调节值"
          signal MCUM_R_Us_Out: start 343, 11 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Us_Out, update-indication-bit-position=-1  # 主右电机Us输出"
          signal MCUM_R_Torque_PwrEst: start 354, 10 bit, little-endian, init-value=500.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Torque_PwrEst, update-indication-bit-position=-1  # 主右电机功率法估算转矩"
          signal MCUM_R_UserDefine_50ms: start 364, 10 bit, little-endian, init-value=500.0, base-type=uint16, implementation-data-type=DT_MCUM_R_UserDefine_50ms, update-indication-bit-position=-1  # 主右电机用户自定义_50ms"
          signal MCUM_R_Torque_ExtChar: start 374, 9 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Torque_ExtChar, update-indication-bit-position=-1  # 主右电机外特性扭矩"
          signal MCUM_R_Damp_CompTorque: start 383, 10 bit, little-endian, init-value=500.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Damp_CompTorque, update-indication-bit-position=-1  # 主右电机防抖补偿转矩"
          signal MCUM_R_Damp_CompCoeff: start 393, 7 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_Damp_CompCoeff, update-indication-bit-position=-1  # 主右电机防抖补偿系数"
          signal MCUM_R_Damp_State: start 400, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_Damp_State, update-indication-bit-position=-1  # 主右电机防抖状态"
          signal MCUM_R_PWM_State: start 401, 2 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_PWM_State, update-indication-bit-position=-1  # 主右电机PWM状态"
          signal MCUM_R_JuncTemp_Max: start 403, 12 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_JuncTemp_Max, update-indication-bit-position=-1  # 主右电机最高结温 "
          signal MCUM_R_JuncLoss_Max: start 415, 13 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_JuncLoss_Max, update-indication-bit-position=-1  # 主右电机控制器最高估算损耗"
          signal MCUM_R_CurrAmp_Comp: start 428, 8 bit, little-endian, init-value=100.0, base-type=uint8, implementation-data-type=DT_MCUM_R_CurrAmp_Comp, update-indication-bit-position=-1  # 主右电机电流幅值补偿值"
          signal MCUM_R_CurrTheta_Comp: start 436, 9 bit, little-endian, init-value=250.0, base-type=uint16, implementation-data-type=DT_MCUM_R_CurrTheta_Comp, update-indication-bit-position=-1  # 主右电机电流角度补偿值"
          signal MCUM_R_RawSinCorr: start 445, 12 bit, little-endian, init-value=2000.0, base-type=uint16, implementation-data-type=DT_MCUM_R_RawSinCorr, update-indication-bit-position=-1  # 主右电机原始电涡流Sin信号"
          signal MCUM_R_RawCosCorr: start 457, 12 bit, little-endian, init-value=2000.0, base-type=uint16, implementation-data-type=DT_MCUM_R_RawCosCorr, update-indication-bit-position=-1  # 主右电机原始电涡流Cos信号"
          signal MCUM_R_LUT_Spd: start 469, 15 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_LUT_Spd, update-indication-bit-position=-1  # 主右查表转速"
      frame MCUM_0x5D2: id 0x5D2, from MVCU, frame-length=64, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu MCUM_0x5D2: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu MCUM_0x5D2: length=64, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.2}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.2}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_R_StatorTemp_1}
            {data-filter={data-filter-type=ALWAYS, max=1023, min=0}, i-signal-in-i-pdu=MCUM_R_L2TqAct}
            {data-filter={data-filter-type=ALWAYS, max=131071, min=0}, i-signal-in-i-pdu=MCUM_R_EOPSw}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_R_StatorTemp_2}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_R_IGBTTemp_U}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_R_IGBTTemp_V}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_R_IGBTTemp_W}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Power_15V}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Offset_IU}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Offset_IV}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Offset_IW}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_MainSt_State}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Derate_Reason}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_PWM_Freq_kHz}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_PWMEn_State}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_DrvPwrEn_Out_State}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_NVM_RslvrZeroRFault}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=3600, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Rotor_Position}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_PosTransduserFaultCode}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_NVM_RslvrDirRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_NVM_RslvrDelayRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_NVM_RslvrParamRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_NVM_HallGainRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_NVM_HallDelayRFault}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_NVM_IGBTTypeRFault}
            {data-filter={data-filter-type=ALWAYS, max=31, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_ASC_EntryCount}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=17000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Spd_Turn}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=17000, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_LUT_Spd_Max}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=8191, min=0}, i-signal-in-i-pdu=MCUM_R_EOP_Speed}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_EOP_IqFb}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_EOP_IqRef}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=300, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_EOP_DCVolt}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_EOP_DCCurr}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MCUM_R_EOP_Temp}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_EOP_State}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_EOP_FaultCode}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HWFault_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HWFoB_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HWFoT_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HWDrvUV_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HWRdc_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HWOC_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_HWOV_RstCnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_L2agRtrElecDiff}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_500usOverTime_Cnt}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_5msOverTime_Cnt}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_CpldRest_TimeOut_flag}
            {data-filter={data-filter-type=ALWAYS, max=30, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_DrvPCBCurr}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_EOL_StateMachine}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_CpldRest_ASC_Flag}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_LimSpdTorFlag}
            {data-filter={data-filter-type=ALWAYS, max=31, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_PWM_Err_Count}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_RDC_Reset_Count}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_ASC_Stop_Flag}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_ASC_Soft_Exiting_Flag}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_Vbus_ServeLowChkEn}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_EOP_BlockErr_IsLim_Flag}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1023, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_IdqErrCount}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_MotSelfHeat_EnSts}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_MotBlockHeat_LvlFb}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_MotRotaryHeat_LvlFb}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_MotSelfHeat_DropLvlFb}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_MotSelfHeat_DropLvlRsn}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=360, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_MotBlockHeat_CurAngle}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=500, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_MotBlockHeat_CurMag}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_UserDefine_Byte{1..4}}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=65535, min=0, offset=0}, i-signal-in-i-pdu=MCUM_R_UserDefine_Word{1..3}}
          signal MCUM_R_StatorTemp_1: start 0, 8 bit, little-endian, init-value=50.0, base-type=uint8, implementation-data-type=DT_MCUM_R_StatorTemp_1, update-indication-bit-position=-1  # 主右电机第一路定子温度"
          signal MCUM_R_L2TqAct: start 306, 10 bit, little-endian, init-value=50.0, base-type=uint16, implementation-data-type=DT_MCUM_R_L2TqAct, update-indication-bit-position=-1  # 主右电机第一路定子温度"
          signal MCUM_R_EOPSw: start 426, 17 bit, little-endian, init-value=50.0, base-type=uint32, implementation-data-type=DT_MCUM_R_EOPSw, update-indication-bit-position=-1  # 主右电机第一路定子温度"
          signal MCUM_R_StatorTemp_2: start 8, 8 bit, little-endian, init-value=50.0, base-type=uint8, implementation-data-type=DT_MCUM_R_StatorTemp_2, update-indication-bit-position=-1  # 主右电机第二路定子温度"
          signal MCUM_R_IGBTTemp_U: start 16, 8 bit, little-endian, init-value=50.0, base-type=uint8, implementation-data-type=DT_MCUM_R_IGBTTemp_U, update-indication-bit-position=-1  # 主右电机U相IGBT壳温"
          signal MCUM_R_IGBTTemp_V: start 24, 8 bit, little-endian, init-value=50.0, base-type=uint8, implementation-data-type=DT_MCUM_R_IGBTTemp_V, update-indication-bit-position=-1  # 主右电机V相IGBT壳温"
          signal MCUM_R_IGBTTemp_W: start 32, 8 bit, little-endian, init-value=50.0, base-type=uint8, implementation-data-type=DT_MCUM_R_IGBTTemp_W, update-indication-bit-position=-1  # 主右电机W相IGBT壳温"
          signal MCUM_R_Power_15V: start 40, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_Power_15V, update-indication-bit-position=-1  # 主右电机控制器15V电压"
          signal MCUM_R_Offset_IU: start 48, 13 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Offset_IU, update-indication-bit-position=-1  # 主右电机U相电流偏移量"
          signal MCUM_R_Offset_IV: start 61, 13 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Offset_IV, update-indication-bit-position=-1  # 主右电机V相电流偏移量"
          signal MCUM_R_Offset_IW: start 74, 13 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Offset_IW, update-indication-bit-position=-1  # 主右电机W相电流偏移量"
          signal MCUM_R_MainSt_State: start 87, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_MainSt_State, update-indication-bit-position=-1  # 主右电机主状态机状态"
          signal MCUM_R_Derate_Reason: start 91, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_Derate_Reason, update-indication-bit-position=-1  # 主右电机扭矩受限原因"
          signal MCUM_R_PWM_Freq_kHz: start 95, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_PWM_Freq_kHz, update-indication-bit-position=-1  # 主右电机载波频率"
          signal MCUM_R_PWMEn_State: start 103, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_PWMEn_State, update-indication-bit-position=-1  # 主右电机PWM缓冲使能状态"
          signal MCUM_R_DrvPwrEn_Out_State: start 104, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_DrvPwrEn_Out_State, update-indication-bit-position=-1  # 主右电机驱动板供电使能状态"
          signal MCUM_R_NVM_RslvrZeroRFault: start 105, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_NVM_RslvrZeroRFault, update-indication-bit-position=-1  # 主右电机位置传感器零点读取失败故障"
          signal MCUM_R_Rotor_Position: start 106, 13 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Rotor_Position, update-indication-bit-position=-1  # 主右电机转子位置角"
          signal MCUM_R_PosTransduserFaultCode: start 119, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_PosTransduserFaultCode, update-indication-bit-position=-1  # 主右电机位置传感器故障码"
          signal MCUM_R_NVM_RslvrDirRFault: start 127, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_NVM_RslvrDirRFault, update-indication-bit-position=-1  # 主右电机位置传感器方向读取失败故障"
          signal MCUM_R_NVM_RslvrDelayRFault: start 128, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_NVM_RslvrDelayRFault, update-indication-bit-position=-1  # 主右电机位置传感器延时读取失败故障"
          signal MCUM_R_NVM_RslvrParamRFault: start 129, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_NVM_RslvrParamRFault, update-indication-bit-position=-1  # 主右电机位置传感器参数读取失败"
          signal MCUM_R_NVM_HallGainRFault: start 130, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_NVM_HallGainRFault, update-indication-bit-position=-1  # 主右电机霍尔增益读取失败"
          signal MCUM_R_NVM_HallDelayRFault: start 131, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_NVM_HallDelayRFault, update-indication-bit-position=-1  # 主右电机霍尔延时读取失败"
          signal MCUM_R_NVM_IGBTTypeRFault: start 132, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_NVM_IGBTTypeRFault, update-indication-bit-position=-1  # 主右电机IGBT型号读取失败"
          signal MCUM_R_ASC_EntryCount: start 133, 5 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_ASC_EntryCount, update-indication-bit-position=-1  # 主右电机实际进入ASC次数统计"
          signal MCUM_R_Spd_Turn: start 138, 15 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_Spd_Turn, update-indication-bit-position=-1  # 主右电机弱磁转折速度"
          signal MCUM_R_LUT_Spd_Max: start 153, 15 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_LUT_Spd_Max, update-indication-bit-position=-1  # 主右电机查表转速最大值"
          signal MCUM_R_EOP_Speed: start 168, 13 bit, little-endian, init-value=4095.5631399317404, base-type=uint16, implementation-data-type=DT_MCUM_R_EOP_Speed, update-indication-bit-position=-1  # 主右电驱油泵转速"
          signal MCUM_R_EOP_IqFb: start 181, 9 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_EOP_IqFb, update-indication-bit-position=-1  # 主右电驱油泵IqFb"
          signal MCUM_R_EOP_IqRef: start 190, 9 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_EOP_IqRef, update-indication-bit-position=-1  # 主右电驱油泵IqRef"
          signal MCUM_R_EOP_DCVolt: start 199, 9 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_EOP_DCVolt, update-indication-bit-position=-1  # 主右电驱油泵母线电压"
          signal MCUM_R_EOP_DCCurr: start 208, 9 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_EOP_DCCurr, update-indication-bit-position=-1  # 主右电驱油泵母线电流"
          signal MCUM_R_EOP_Temp: start 217, 8 bit, little-endian, init-value=50.0, base-type=uint8, implementation-data-type=DT_MCUM_R_EOP_Temp, update-indication-bit-position=-1  # 主右电驱油泵温度"
          signal MCUM_R_EOP_State: start 225, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_EOP_State, update-indication-bit-position=-1  # 主右电驱油泵状态"
          signal MCUM_R_EOP_FaultCode: start 229, 3 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_EOP_FaultCode, update-indication-bit-position=-1  # 主右电驱油泵故障码"
          signal MCUM_R_HWFault_RstCnt: start 232, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HWFault_RstCnt, update-indication-bit-position=-1  # 主右电机硬件故障复位计数"
          signal MCUM_R_HWFoB_RstCnt: start 236, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HWFoB_RstCnt, update-indication-bit-position=-1  # 主右电机下桥Fo故障复位计数"
          signal MCUM_R_HWFoT_RstCnt: start 240, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HWFoT_RstCnt, update-indication-bit-position=-1  # 主右电机上桥Fo故障复位计数"
          signal MCUM_R_HWDrvUV_RstCnt: start 244, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HWDrvUV_RstCnt, update-indication-bit-position=-1  # 主右电机驱动欠压故障复位计数"
          signal MCUM_R_HWRdc_RstCnt: start 248, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HWRdc_RstCnt, update-indication-bit-position=-1  # 主右电机旋变故障复位计数"
          signal MCUM_R_HWOC_RstCnt: start 252, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HWOC_RstCnt, update-indication-bit-position=-1  # 主右电机硬件过流故障复位计数"
          signal MCUM_R_HWOV_RstCnt: start 256, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_HWOV_RstCnt, update-indication-bit-position=-1  # 主右主电机硬件过压故障复位计数"
          signal MCUM_R_L2agRtrElecDiff: start 260, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_L2agRtrElecDiff, update-indication-bit-position=-1  # 主右电机中断超时计数"
          signal MCUM_R_500usOverTime_Cnt: start 264, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_500usOverTime_Cnt, update-indication-bit-position=-1  # 主右电机0.5ms超时计数"
          signal MCUM_R_5msOverTime_Cnt: start 268, 4 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_5msOverTime_Cnt, update-indication-bit-position=-1  # 主右电机5ms超时计数"
          signal MCUM_R_CpldRest_TimeOut_flag: start 272, 2 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_CpldRest_TimeOut_flag, update-indication-bit-position=-1  # 主右电机初始化阶段计数超时标志位"
          signal MCUM_R_DrvPCBCurr: start 274, 5 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_DrvPCBCurr, update-indication-bit-position=-1  # 主右电机控制器驱动板供电电流"
          signal MCUM_R_EOL_StateMachine: start 279, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_EOL_StateMachine, update-indication-bit-position=-1  # 主右电机下线状态机"
          signal MCUM_R_CpldRest_ASC_Flag: start 287, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_CpldRest_ASC_Flag, update-indication-bit-position=-1  # 主右电机故障处置中标志"
          signal MCUM_R_LimSpdTorFlag: start 288, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_LimSpdTorFlag, update-indication-bit-position=-1  # 主右电机限速限扭故障"
          signal MCUM_R_PWM_Err_Count: start 289, 5 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_PWM_Err_Count, update-indication-bit-position=-1  # 主右电机Us异常检测复位次数"
          signal MCUM_R_RDC_Reset_Count: start 294, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_RDC_Reset_Count, update-indication-bit-position=-1  # 主右电机位置传感器复位次数"
          signal MCUM_R_ASC_Stop_Flag: start 302, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_ASC_Stop_Flag, update-indication-bit-position=-1  # 主右电机ASC退出标志"
          signal MCUM_R_ASC_Soft_Exiting_Flag: start 303, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_ASC_Soft_Exiting_Flag, update-indication-bit-position=-1  # 主右电机ASC软退出进行中标志"
          signal MCUM_R_Vbus_ServeLowChkEn: start 304, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_Vbus_ServeLowChkEn, update-indication-bit-position=-1  # 主右电机母线严重欠压故障检测使能标志"
          signal MCUM_R_EOP_BlockErr_IsLim_Flag: start 305, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_EOP_BlockErr_IsLim_Flag, update-indication-bit-position=-1  # 主右电驱油泵堵转限电流输出标志"
          signal MCUM_R_IdqErrCount: start 306, 11 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_IdqErrCount, update-indication-bit-position=-1  # 主右电机Idq异常计数"
          signal MCUM_R_MotSelfHeat_EnSts: start 317, 2 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_MotSelfHeat_EnSts, update-indication-bit-position=-1  # 主右电机制热使能标志位"
          signal MCUM_R_MotBlockHeat_LvlFb: start 319, 3 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_MotBlockHeat_LvlFb, update-indication-bit-position=-1  # 主右电机静止制热等级反馈"
          signal MCUM_R_MotRotaryHeat_LvlFb: start 322, 3 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_MotRotaryHeat_LvlFb, update-indication-bit-position=-1  # 主右电机行车制热等级反馈"
          signal MCUM_R_MotSelfHeat_DropLvlFb: start 325, 1 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_MotSelfHeat_DropLvlFb, update-indication-bit-position=-1  # 主右电机制热主动降档反馈"
          signal MCUM_R_MotSelfHeat_DropLvlRsn: start 326, 2 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_MotSelfHeat_DropLvlRsn, update-indication-bit-position=-1  # 主右电机制热主动降档原因"
          signal MCUM_R_MotBlockHeat_CurAngle: start 328, 9 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_MotBlockHeat_CurAngle, update-indication-bit-position=-1  # 主右电机静止制热电流注入电角度"
          signal MCUM_R_MotBlockHeat_CurMag: start 337, 9 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_MotBlockHeat_CurMag, update-indication-bit-position=-1  # 主右电机静止制热电流幅值"
          signal MCUM_R_UserDefine_Byte1: start 346, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_UserDefine_Byte1, update-indication-bit-position=-1  # 主右电机用户自定义_Byte1"
          signal MCUM_R_UserDefine_Byte2: start 354, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_UserDefine_Byte2, update-indication-bit-position=-1  # 主右电机用户自定义_Byte2"
          signal MCUM_R_UserDefine_Byte3: start 362, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_UserDefine_Byte3, update-indication-bit-position=-1  # 主右电机用户自定义_Byte3"
          signal MCUM_R_UserDefine_Byte4: start 370, 8 bit, little-endian, init-value=0.0, base-type=uint8, implementation-data-type=DT_MCUM_R_UserDefine_Byte4, update-indication-bit-position=-1  # 主右电机用户自定义_Byte4"
          signal MCUM_R_UserDefine_Word1: start 378, 16 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_UserDefine_Word1, update-indication-bit-position=-1  # 主右电机用户自定义_Word1"
          signal MCUM_R_UserDefine_Word2: start 394, 16 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_UserDefine_Word2, update-indication-bit-position=-1  # 主右电机用户自定义_Word2"
          signal MCUM_R_UserDefine_Word3: start 410, 16 bit, little-endian, init-value=0.0, base-type=uint16, implementation-data-type=DT_MCUM_R_UserDefine_Word3, update-indication-bit-position=-1  # 主右电机用户自定义_Word3"
      frame VCU_0x515: id 0x515, from MVCU, frame-length=8, can-addressing-mode=STANDARD, can-fd-frame-support=true, can-frame-tx-behavior=CAN-FD
        carries pdu VCU_0x515: packing-byte-order=little-endian, start-position=0, update-indication-bit-position=-1
        pdu VCU_0x515: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.2}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.2}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=254, min=0, offset=0}, i-signal-in-i-pdu=VCU_Pending_DTC}
            {data-filter={data-filter-type=ALWAYS, max=254, min=0, offset=0}, i-signal-in-i-pdu=VCU_Comfirmed_DTC}
            {data-filter={data-filter-type=ALWAYS, max=254, min=0, offset=0}, i-signal-in-i-pdu=VCU_Permanent_DTC}
            {data-filter={data-filter-type=ALWAYS, max=254, min=0, offset=0}, i-signal-in-i-pdu=VCU_MilReq_DTC}
          signal VCU_Pending_DTC: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_Pending_DTC, update-indication-bit-position=-1
          signal VCU_Comfirmed_DTC: start 8, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_Comfirmed_DTC, update-indication-bit-position=-1
          signal VCU_Permanent_DTC: start 16, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_Permanent_DTC, update-indication-bit-position=-1
          signal VCU_MilReq_DTC: start 24, 8 bit, little-endian, init-value=0, base-type=uint8, implementation-data-type=DT_VCU_MilReq_DTC, update-indication-bit-position=-1
